# Keil uVision project standart.uvprojx, settings and files
target gpio (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: standart
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F103xB
  c include: ..\stm32cubef1\STM32Cube_FW_F1_V1.0.0\Drivers\CMSIS\Include;..\stm32cubef1\STM32Cube_FW_F1_V1.0.0\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\stm32cubef1\STM32Cube_FW_F1_V1.0.0\Drivers\CMSIS\Device\ST\STM32F1xx\Source\Templates;..\stm32cubef1\STM32Cube_FW_F1_V1.0.0\Drivers\CMSIS\Device\ST\STM32F1xx\Source\Templates\arm
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group General
    ./: system_stm32f1xx.c startup_stm32f103xb.s
  group Include
    ./: Lib.c Lib.h
  group Source
    ./: main.c Led.c Led.h
